File: buck.kicad_sch (KiCad schematic)
At the start: 27 parts, among them Q5 CSD18543Q3A, Q6 CSD18543Q3A

Commit message: major docs changes
Parts:
- U15: value ~ -> (none)
